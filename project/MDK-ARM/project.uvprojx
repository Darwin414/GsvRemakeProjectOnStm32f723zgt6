# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../../Middlewares/ThirdParty/SEGGER/Config;../../Middlewares/ThirdParty/SEGGER/RTT;../Drivers/Gsv650x/userapp/stm32f030c8_gsv6505_gsv_demo/apps;../Drivers/Gsv650x/kapi;../Drivers/Gsv650x/uapi;../Drivers/Gsv650x/uapi/gsv6k5_r1_reg;../Drivers/Gsv650x/userbsp/keil/stm32f070cb_gsv6505_gsv_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/Gsv650x/GSV_apps
    ../Drivers/Gsv650x/userapp/stm32f030c8_gsv6505_gsv_demo/apps/: av_common.c av_earc_manage.c av_edid_manage.c av_event_handler.c av_irda_cmd.c av_key_cmd.c av_main.c av_uart_cmd.c
  group Drivers/Gsv650x/GSV_kapi
    ../Drivers/Gsv650x/kapi/: kapi.c kapi_debug_info.c kernel_fsm.c kernel_status_update.c uapi_function_mapper.c
  group Drivers/Gsv650x/GSV_uapi
    ../Drivers/Gsv650x/uapi/: gsv6k5.c hal.c uapi.c
  group Drivers/Gsv650x/GSV_userbsp
    ../Drivers/Gsv650x/userbsp/keil/stm32f070cb_gsv6505_gsv_demo/: bsp.c
  group Middlewares/RTT
    ../../Middlewares/ThirdParty/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 6.2.0
